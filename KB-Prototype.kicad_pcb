# Repository DoesItRlyMatter/KB-Prototype

File README.md:

# KB-Prototype
Testing some stuff.

## KiCad design KB-Prototype.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric
C2, C3, C4: 0.1uF; C_0805_2012Metric
C5: 10uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9: BAT54C; SOT-23
H1, H2, H3, H4: MountingHole; Generic-Mounthole
J1, J2, J3: Conn_01x04; JST-SR-4
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18: MX-NoLED; MXOnly-1U-NoLED
R1, R6, R7: 10k; R_0805_2012Metric
R2, R3: 4.7k; R_0805_2012Metric
R4, R5: 22; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: Resonator_Small; CSTCE

Connections:
+5V: C2.2, C3.2, C4.2, C5.2, J1.1, J2.1, J3.1, R1.1, R2.1, R3.1, R7.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), MX7.1 (COL), MX13.1 (COL), U1.9 (PB1)
COL1: MX2.1 (COL), MX8.1 (COL), MX14.1 (COL), U1.8 (PB0)
COL2: MX3.1 (COL), MX9.1 (COL), MX15.1 (COL), U1.41 (PF0)
COL3: MX4.1 (COL), MX10.1 (COL), MX16.1 (COL), U1.40 (PF1)
COL4: MX5.1 (COL), MX11.1 (COL), MX17.1 (COL), U1.39 (PF4)
COL5: MX6.1 (COL), MX12.1 (COL), MX18.1 (COL), U1.38 (PF5)
D+: J2.3, R4.2
D-: J2.2, R5.2
GND: C1.2, C2.1, C3.1, C4.1, C5.1, J1.4, J2.4, J3.4, R6.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), Y1.2
unnamed: C1.1, U1.6 (UCAP)
unnamed: D1.1, MX1.2 (ROW)
unnamed: D1.2, MX2.2 (ROW)
unnamed: D2.1, MX3.2 (ROW)
unnamed: D2.2, MX4.2 (ROW)
unnamed: D3.1, MX5.2 (ROW)
unnamed: D3.2, MX6.2 (ROW)
unnamed: D4.1, MX7.2 (ROW)
unnamed: D4.2, MX8.2 (ROW)
unnamed: D5.1, MX9.2 (ROW)
unnamed: D5.2, MX10.2 (ROW)
unnamed: D6.1, MX11.2 (ROW)
unnamed: D6.2, MX12.2 (ROW)
unnamed: D7.1, MX13.2 (ROW)
unnamed: D7.2, MX14.2 (ROW)
unnamed: D8.1, MX15.2 (ROW)
unnamed: D8.2, MX16.2 (ROW)
unnamed: D9.1, MX17.2 (ROW)
unnamed: D9.2, MX18.2 (ROW)
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R4.1, U1.4 (D+)
unnamed: R5.1, U1.3 (D-)
unnamed: R6.2, U1.33 (~HWB~/PE2)
unnamed: R7.2, U1.36 (PF7)
unnamed: U1.16 (XTAL2), Y1.3
unnamed: U1.17 (XTAL1), Y1.1
ROW0: D1.3, D2.3, D3.3, U1.11 (PB3)
ROW1: D4.3, D5.3, D6.3, U1.10 (PB2)
ROW2: D7.3, D8.3, D9.3, U1.37 (PF6)
SCL: J1.2, J3.2, R3.2, U1.18 (PD0)
SDA: J1.3, J3.3, R2.2, U1.19 (PD1)

Board: 2 copper layers, 145.3 x 57.2 mm, 49 parts (26 on the bottom side), 41 nets.

## Commit log

2020-07-11 added submodules
2020-07-11 added footprint libraries
2020-07-11 sch 90% done
2020-07-11 assigned footprints for components
2020-07-11 pcb routed, except rows/cols
2020-07-11 hooked up cols/row, added silkscreen
2020-07-11 added mounting holes
2020-07-12 generated gerbers
